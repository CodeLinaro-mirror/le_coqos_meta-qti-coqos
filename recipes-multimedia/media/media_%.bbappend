FILESEXTRAPATHS_append := ":${THISDIR}/files"

SRC_URI_append = " file://0001-vdec-Keep-last-port-reconfiguration-event-in-the-que.patch"
