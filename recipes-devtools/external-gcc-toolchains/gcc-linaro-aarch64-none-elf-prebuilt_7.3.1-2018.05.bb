PR = "r1"

require repository-config.inc

TYPE = "tar.xz"

require gcc-linaro-aarch64-none-elf-prebuilt.inc

SRC_URI[gcc-linaro-linux-x86_64.md5sum] = "89b6b05c557243fb5d029f3916023121"
SRC_URI[gcc-linaro-linux-x86_64.sha256sum] = "e73d1886fb67d5a03c0ca5be14aeab6b7b7be3fce46ad1473ba864d5eb1d2545"
