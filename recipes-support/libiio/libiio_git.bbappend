SRC_URI = "git://github.com/analogdevicesinc/libiio.git;protocol=https;branch=main"
