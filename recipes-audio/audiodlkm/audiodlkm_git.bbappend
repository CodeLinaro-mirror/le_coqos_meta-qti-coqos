FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://6065069_0001-asoc-ADSP-Stream-Cmd-not-works-correctly-during-mult.patch \
"
