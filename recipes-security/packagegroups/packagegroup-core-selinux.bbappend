RDEPENDS_${PN}_remove = "selinux-autorelabel"
