IMAGE_INSTALL += "\
    packagegroup-coqos-base \
    "

# supplementary debugging and development tools
IMAGE_INSTALL += "\
    packagegroup-core-tools-debug \
    ltrace \
    socat \
    "
