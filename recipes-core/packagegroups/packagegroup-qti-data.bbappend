RDEPENDS:${PN}:remove = "\
    connman \
    connman-client \
"
